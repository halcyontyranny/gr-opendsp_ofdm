options:
  parameters:
    author: KF0UXU
    description: OpenDSP OFDM adaptive HF modem — audio loopback / soundcard demo. Connect TX audio out to RX audio in (via cable or soundcard loopback) to test end-to-end. Sample rate must be 8000 Hz on both source and sink.
    generate_options: qt_gui
    id: opendsp_ofdm_audio_demo
    output_language: python
    title: OpenDSP OFDM Audio Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Must be 8000 — the opendsp-ofdm modem is designed for 8 kHz (SSB passband). If your soundcard does not support 8000 sps natively, insert a rational_resampler between the audio blocks and the modem blocks.
    value: '8000'
  states: {}
- name: callsign
  id: variable
  parameters:
    comment: Your station callsign (up to 6 chars). Change here to update both TX and RX.
    value: '"N0CALL"'
  states: {}
- name: force_tier
  id: variable
  parameters:
    comment: 'ACM tier override: -1 = adaptive, 0-8 = forced. Tier 0 = 50 Hz survival (~100 s/msg), Tier 4 = 2 kHz QPSK (~1 kbps).'
    value: '-1'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: TX
    label1: RX
    num_tabs: '2'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: Type a message and press Enter to transmit. The modem encodes the text, applies LDPC FEC, and streams the OFDM waveform to the audio sink.
    gui_hint: tab@0:0,0,1,2
    is_pair: 'False'
    is_static: 'False'
    label: '"Transmit Message (press Enter)"'
    type: string
    value: '"Hello via OFDM!"'
  states: {}
- name: opendsp_ofdm_tx_source_0
  id: opendsp_ofdm_tx_source
  parameters:
    callsign: callsign
    comment: Receives text messages on msg_in, outputs OFDM float32 samples at 8000 sps. Output is silent (zeros) between transmissions.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Connect physical TX audio output to your radio line-in or use a virtual audio cable for loopback testing.
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'Shows the OFDM signal spectrum. The occupied bandwidth shifts with ACM tier: 50 Hz (tier 0) through 3.5 kHz (tier 8).'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:1,0,1,2
    label: '"TX Spectrum"'
    name: '"TX Spectrum"'
    type: float
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Connect physical RX audio input from your radio line-out or use a virtual audio cable for loopback testing.
    samp_rate: samp_rate
  states: {}
- name: opendsp_ofdm_rx_sink_0
  id: opendsp_ofdm_rx_sink
  parameters:
    callsign: callsign
    comment: 'Demodulates incoming OFDM samples. Decoded frames are posted to frame_out as PDU pairs: pmt.cons({"callsign":..,"tier":..,"fec_ok":..}, text). The verbose flag also prints decoded frames and SNR to the console.'
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: 'Decoded frames printed here and in the GRC console. PDU format: ({"callsign":"W1AW","tier":3,"fec_ok":True}, "Hello via OFDM!")'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Shows incoming audio spectrum. Watch for the OFDM signal to appear in the 500–3500 Hz range when a remote station is transmitting.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@1:0,0,1,2
    label: '"RX Spectrum"'
    name: '"RX Spectrum"'
    type: float
  states: {}

connections:
- [opendsp_ofdm_tx_source_0, '0', audio_sink_0, '0']
- [opendsp_ofdm_tx_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', opendsp_ofdm_rx_sink_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_1, '0']
- [qtgui_edit_box_msg_0, msg, opendsp_ofdm_tx_source_0, msg_in]
- [opendsp_ofdm_rx_sink_0, frame_out, blocks_message_debug_0, print]

metadata:
  file_format: 1
