options:
  parameters:
    author: KF0UXU
    description: OpenDSP OFDM dual-HackRF demo -- two independent half-duplex stations sharing center_freq. Set hackrf_a_args / hackrf_b_args to select devices (e.g. hackrf=0, hackrf=1, or hackrf=<serial>).
    generate_options: qt_gui
    id: opendsp_ofdm_hackrf_dual_demo
    output_language: python
    title: OpenDSP OFDM -- Dual HackRF Demo
  states: {}

blocks:
- name: callsign_a
  id: variable
  parameters:
    comment: Callsign for Station A (embedded in every TX frame).
    value: '"KF0UXU"'
  states: {}
- name: callsign_b
  id: variable
  parameters:
    comment: Callsign for Station B.
    value: '"N0CALL"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Shared dial frequency in Hz. Both HackRFs tune here for loopback testing.
    value: 432.1e6
  states: {}
- name: force_tier
  id: variable
  parameters:
    comment: 'ACM tier override: -1 = adaptive. 0=50 Hz survival, 4=2 kHz QPSK, 8=3.5 kHz 16QAM.'
    value: '4'
  states: {}
- name: hackrf_a_args
  id: variable
  parameters:
    comment: Device string for HackRF A. Use hackrf=0, hackrf=1, or hackrf=<serial>.
    value: '"hackrf=0"'
  states: {}
- name: hackrf_b_args
  id: variable
  parameters:
    comment: Device string for HackRF B. Use hackrf=0, hackrf=1, or hackrf=<serial>.
    value: '"hackrf=1"'
  states: {}
- name: hackrf_rate
  id: variable
  parameters:
    comment: HackRF sample rate. 2 MHz minimum; gives 250:1 resampling ratio.
    value: '2000000'
  states: {}
- name: rx_bb_gain
  id: variable
  parameters:
    comment: HackRF RX baseband (VGA) gain (dB). 0-62 dB in 2 dB steps.
    value: '16'
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    comment: HackRF RX IF (LNA) gain (dB). 0-40 dB in 8 dB steps.
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Modem audio rate -- fixed at 8000 Hz.
    value: '8000'
  states: {}
- name: transmit_a
  id: variable
  parameters:
    comment: TX state for Station A -- controlled by send_gate_a via set_transmit_a.
    value: 'False'
  states: {}
- name: transmit_b
  id: variable
  parameters:
    comment: TX state for Station B -- controlled by send_gate_b via set_transmit_b.
    value: 'False'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: HackRF TX IF gain (dB). 0-47 dB in 1 dB steps.
    value: '47'
  states: {}
- name: blocks_complex_to_float_a
  id: blocks_complex_to_float
  parameters:
    comment: Station A USB demod -- take I (real) channel.
  states: {}
- name: blocks_complex_to_float_b
  id: blocks_complex_to_float
  parameters:
    comment: Station B USB demod -- take I (real) channel.
  states: {}
- name: blocks_message_debug_a
  id: blocks_message_debug
  parameters:
    comment: Station A decoded frames -- printed to GRC console.
  states: {}
- name: blocks_message_debug_b
  id: blocks_message_debug
  parameters:
    comment: Station B decoded frames -- printed to GRC console.
  states: {}
- name: hilbert_fc_a
  id: hilbert_fc
  parameters:
    comment: Station A USB analytic signal (real float -> complex IQ).
    num_taps: '65'
  states: {}
- name: hilbert_fc_b
  id: hilbert_fc
  parameters:
    comment: Station B USB analytic signal (real float -> complex IQ).
    num_taps: '65'
  states: {}
- name: opendsp_ofdm_rx_sink_a
  id: opendsp_ofdm_rx_sink
  parameters:
    callsign: callsign_a
    comment: Station A OFDM RX. Decoded frames posted to frame_out.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: opendsp_ofdm_rx_sink_b
  id: opendsp_ofdm_rx_sink
  parameters:
    callsign: callsign_b
    comment: Station B OFDM RX. Decoded frames posted to frame_out.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: opendsp_ofdm_tx_source_a
  id: opendsp_ofdm_tx_source
  parameters:
    callsign: callsign_a
    comment: Station A OFDM TX. Outputs real 8 kHz OFDM audio.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: opendsp_ofdm_tx_source_b
  id: opendsp_ofdm_tx_source
  parameters:
    callsign: callsign_b
    comment: Station B OFDM TX. Outputs real 8 kHz OFDM audio.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: osmosdr_transceiver_a
  id: osmosdr_transceiver
  parameters:
    args: hackrf_a_args
    bandwidth: '0'
    center_freq: center_freq
    comment: HackRF A half-duplex transceiver. transmit_a controls TX/RX switching.
    freq_corr: '0'
    rf_gain: '0'
    rx_bb_gain: rx_bb_gain
    rx_if_gain: rx_if_gain
    sample_rate: hackrf_rate
    transmit: transmit_a
    tx_gain: tx_gain
  states: {}
- name: osmosdr_transceiver_b
  id: osmosdr_transceiver
  parameters:
    args: hackrf_b_args
    bandwidth: '0'
    center_freq: center_freq
    comment: HackRF B half-duplex transceiver. transmit_b controls TX/RX switching.
    freq_corr: '0'
    rf_gain: '0'
    rx_bb_gain: rx_bb_gain
    rx_if_gain: rx_if_gain
    sample_rate: hackrf_rate
    transmit: transmit_b
    tx_gain: tx_gain
  states: {}
- name: qtgui_const_sink_rx_a
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.8'
    comment: Station A RX IQ constellation at 8 kHz (shows modulation symbol cloud).
    gui_hint: tab@1:2,0,1,2
    name: '"A: RX IQ Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_rx_b
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.8'
    comment: Station B RX IQ constellation at 8 kHz.
    gui_hint: tab@3:2,0,1,2
    name: '"B: RX IQ Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_a
  id: qtgui_edit_box_msg
  parameters:
    comment: Station A TX input. Type message and press Enter to buffer, then click Send A.
    gui_hint: tab@0:0,0,1,2
    is_pair: 'False'
    is_static: 'False'
    label: '"A: type message + Enter to buffer, then click Send A"'
    type: string
    value: '"Hello from Station A!"'
  states: {}
- name: qtgui_edit_box_msg_b
  id: qtgui_edit_box_msg
  parameters:
    comment: Station B TX input. Type message and press Enter to buffer, then click Send B.
    gui_hint: tab@2:0,0,1,2
    is_pair: 'False'
    is_static: 'False'
    label: '"B: type message + Enter to buffer, then click Send B"'
    type: string
    value: '"Hello from Station B!"'
  states: {}
- name: qtgui_edit_box_msg_rx_a
  id: qtgui_edit_box_msg
  parameters:
    comment: Last decoded message received at Station A. Updated on each decoded frame.
    gui_hint: tab@1:3,0,1,2
    key: decoded
    label: '"Last Received at A"'
    type: string
    value: '"(none yet)"'
  states: {}
- name: qtgui_edit_box_msg_rx_b
  id: qtgui_edit_box_msg
  parameters:
    comment: Last decoded message received at Station B.
    gui_hint: tab@3:3,0,1,2
    key: decoded
    label: '"Last Received at B"'
    type: string
    value: '"(none yet)"'
  states: {}
- name: qtgui_freq_sink_rx_a
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: hackrf_rate
    comment: Station A wideband HF spectrum from HackRF A (2 MHz span).
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@1:0,0,1,2
    label: '"A: HackRF RX Spectrum"'
    name: '"A: HackRF RX Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_rx_b
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: hackrf_rate
    comment: Station B wideband HF spectrum from HackRF B (2 MHz span).
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@3:0,0,1,2
    label: '"B: HackRF RX Spectrum"'
    name: '"B: HackRF RX Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_tx_a
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Station A TX audio spectrum. Bandwidth shifts with ACM tier.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:1,0,1,2
    label: '"A: TX Audio Spectrum"'
    name: '"A: TX Audio Spectrum"'
    type: float
  states: {}
- name: qtgui_freq_sink_tx_b
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: Station B TX audio spectrum. Bandwidth shifts with ACM tier.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@2:1,0,1,2
    label: '"B: TX Audio Spectrum"'
    name: '"B: TX Audio Spectrum"'
    type: float
  states: {}
- name: qtgui_time_sink_rx_a
  id: qtgui_time_sink_x
  parameters:
    comment: Station A RX IQ time domain at 8 kHz -- I (blue) and Q (red).
    grid: 'True'
    gui_hint: tab@1:1,0,1,2
    label1: I
    label2: Q
    name: '"A: RX IQ"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_rx_b
  id: qtgui_time_sink_x
  parameters:
    comment: Station B RX IQ time domain at 8 kHz -- I (blue) and Q (red).
    grid: 'True'
    gui_hint: tab@3:1,0,1,2
    label1: I
    label2: Q
    name: '"B: RX IQ"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_tx_a
  id: qtgui_time_sink_x
  parameters:
    comment: Station A TX IQ at 8 kHz (hilbert output) -- I (blue) and Q (red).
    grid: 'True'
    gui_hint: tab@0:2,0,1,2
    label1: I
    label2: Q
    name: '"A: TX IQ"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_tx_b
  id: qtgui_time_sink_x
  parameters:
    comment: Station B TX IQ at 8 kHz (hilbert output) -- I (blue) and Q (red).
    grid: 'True'
    gui_hint: tab@2:2,0,1,2
    label1: I
    label2: Q
    name: '"B: TX IQ"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_rx_a
  id: rational_resampler_xxx
  parameters:
    comment: Station A RX downsample 2 MHz -> 8 kHz (/250).
    decim: '250'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_rx_b
  id: rational_resampler_xxx
  parameters:
    comment: Station B RX downsample 2 MHz -> 8 kHz (/250).
    decim: '250'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_tx_a
  id: rational_resampler_xxx
  parameters:
    comment: Station A TX upsample 8 kHz -> 2 MHz (x250).
    decim: '1'
    interp: '250'
    type: ccc
  states: {}
- name: rational_resampler_tx_b
  id: rational_resampler_xxx
  parameters:
    comment: Station B TX upsample 8 kHz -> 2 MHz (x250).
    decim: '1'
    interp: '250'
    type: ccc
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: A-TX
    label1: A-RX
    label2: B-TX
    label3: B-RX
    num_tabs: '4'
  states: {}
- name: send_btn_a
  id: variable_qtgui_push_button
  parameters:
    comment: Click to enable TX and transmit buffered message for Station A.
    gui_hint: 0,0,1,1
    label: '"Send A"'
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: stop_btn_a
  id: variable_qtgui_push_button
  parameters:
    comment: Click to stop TX and return Station A to RX mode.
    gui_hint: 0,1,1,1
    label: '"Stop TX A"'
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: send_btn_b
  id: variable_qtgui_push_button
  parameters:
    comment: Click to enable TX and transmit buffered message for Station B.
    gui_hint: 0,2,1,1
    label: '"Send B"'
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: stop_btn_b
  id: variable_qtgui_push_button
  parameters:
    comment: Click to stop TX and return Station B to RX mode.
    gui_hint: 0,3,1,1
    label: '"Stop TX B"'
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: send_gate_a
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Send Gate: buffers edit-box message and enables TX when Send A is clicked.\nStop TX A disables TX."""

          def __init__(self, set_ptt_cb=None, send_trigger=False, stop_trigger=False):
              gr.basic_block.__init__(self, name='SendGate', in_sig=None, out_sig=None)
              self._set_ptt = set_ptt_cb
              self._pending = None
              self._send_trigger = bool(send_trigger)
              self._stop_trigger = bool(stop_trigger)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self._on_msg)

          def _on_msg(self, msg):
              self._pending = msg

          @property
          def send_trigger(self):
              return self._send_trigger

          @send_trigger.setter
          def send_trigger(self, val):
              val = bool(val)
              if val and not self._send_trigger:
                  if self._set_ptt is not None:
                      self._set_ptt(True)
                  if self._pending is not None:
                      self.message_port_pub(pmt.intern('msg_out'), self._pending)
              self._send_trigger = val

          @property
          def stop_trigger(self):
              return self._stop_trigger

          @stop_trigger.setter
          def stop_trigger(self, val):
              val = bool(val)
              if val and not self._stop_trigger:
                  if self._set_ptt is not None:
                      self._set_ptt(False)
              self._stop_trigger = val
    send_trigger: send_btn_a
    set_ptt_cb: 'lambda v: self.set_transmit_a(v)'
    stop_trigger: stop_btn_a
  states: {}
- name: send_gate_b
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Send Gate: buffers edit-box message and enables TX when Send B is clicked.\nStop TX B disables TX."""

          def __init__(self, set_ptt_cb=None, send_trigger=False, stop_trigger=False):
              gr.basic_block.__init__(self, name='SendGate', in_sig=None, out_sig=None)
              self._set_ptt = set_ptt_cb
              self._pending = None
              self._send_trigger = bool(send_trigger)
              self._stop_trigger = bool(stop_trigger)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self._on_msg)

          def _on_msg(self, msg):
              self._pending = msg

          @property
          def send_trigger(self):
              return self._send_trigger

          @send_trigger.setter
          def send_trigger(self, val):
              val = bool(val)
              if val and not self._send_trigger:
                  if self._set_ptt is not None:
                      self._set_ptt(True)
                  if self._pending is not None:
                      self.message_port_pub(pmt.intern('msg_out'), self._pending)
              self._send_trigger = val

          @property
          def stop_trigger(self):
              return self._stop_trigger

          @stop_trigger.setter
          def stop_trigger(self, val):
              val = bool(val)
              if val and not self._stop_trigger:
                  if self._set_ptt is not None:
                      self._set_ptt(False)
              self._stop_trigger = val
    send_trigger: send_btn_b
    set_ptt_cb: 'lambda v: self.set_transmit_b(v)'
    stop_trigger: stop_btn_b
  states: {}

connections:
- [blocks_complex_to_float_a, '0', opendsp_ofdm_rx_sink_a, '0']
- [blocks_complex_to_float_b, '0', opendsp_ofdm_rx_sink_b, '0']
- [hilbert_fc_a, '0', qtgui_time_sink_tx_a, '0']
- [hilbert_fc_a, '0', rational_resampler_tx_a, '0']
- [hilbert_fc_b, '0', qtgui_time_sink_tx_b, '0']
- [hilbert_fc_b, '0', rational_resampler_tx_b, '0']
- [opendsp_ofdm_rx_sink_a, frame_out, blocks_message_debug_a, print]
- [opendsp_ofdm_rx_sink_a, frame_out, qtgui_edit_box_msg_rx_a, val]
- [opendsp_ofdm_rx_sink_b, frame_out, blocks_message_debug_b, print]
- [opendsp_ofdm_rx_sink_b, frame_out, qtgui_edit_box_msg_rx_b, val]
- [opendsp_ofdm_tx_source_a, '0', hilbert_fc_a, '0']
- [opendsp_ofdm_tx_source_a, '0', qtgui_freq_sink_tx_a, '0']
- [opendsp_ofdm_tx_source_b, '0', hilbert_fc_b, '0']
- [opendsp_ofdm_tx_source_b, '0', qtgui_freq_sink_tx_b, '0']
- [osmosdr_transceiver_a, '0', qtgui_freq_sink_rx_a, '0']
- [osmosdr_transceiver_a, '0', rational_resampler_rx_a, '0']
- [osmosdr_transceiver_b, '0', qtgui_freq_sink_rx_b, '0']
- [osmosdr_transceiver_b, '0', rational_resampler_rx_b, '0']
- [qtgui_edit_box_msg_a, msg, send_gate_a, msg_in]
- [qtgui_edit_box_msg_b, msg, send_gate_b, msg_in]
- [send_gate_a, msg_out, opendsp_ofdm_tx_source_a, msg_in]
- [send_gate_b, msg_out, opendsp_ofdm_tx_source_b, msg_in]
- [rational_resampler_rx_a, '0', blocks_complex_to_float_a, '0']
- [rational_resampler_rx_a, '0', qtgui_const_sink_rx_a, '0']
- [rational_resampler_rx_a, '0', qtgui_time_sink_rx_a, '0']
- [rational_resampler_rx_b, '0', blocks_complex_to_float_b, '0']
- [rational_resampler_rx_b, '0', qtgui_const_sink_rx_b, '0']
- [rational_resampler_rx_b, '0', qtgui_time_sink_rx_b, '0']
- [rational_resampler_tx_a, '0', osmosdr_transceiver_a, '0']
- [rational_resampler_tx_b, '0', osmosdr_transceiver_b, '0']

metadata:
  file_format: 1
