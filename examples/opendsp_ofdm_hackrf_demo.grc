options:
  parameters:
    author: KF0UXU
    description: |-
      OpenDSP OFDM on HackRF -- adaptive HF OFDM via osmosdr_transceiver.

      Signal chain:
        TX: opendsp_ofdm_tx_source (float, 8 kHz)
              -> hilbert_fc (float->complex analytic/USB signal)
              -> rational_resampler (x250, 8 kHz->2 MHz)
              -> osmosdr_transceiver (HackRF TX)
        RX: osmosdr_transceiver (HackRF RX)
              -> rational_resampler (/250, 2 MHz->8 kHz)
              -> complex_to_float (USB demod: take I channel)
              -> opendsp_ofdm_rx_sink

      Frequency planning: set center_freq to your dial frequency (e.g. 14.074 MHz
      for 20m digital). The OFDM signal occupies center_freq + 500 Hz to
      center_freq + 3500 Hz (USB convention).

      PTT: check the PTT box BEFORE pressing Enter in the TX message field.
      Uncheck PTT once the transmission finishes to return to receive.
    generate_options: qt_gui
    id: opendsp_ofdm_hackrf_demo
    output_language: python
    title: OpenDSP OFDM — HackRF Demo
  states: {}

blocks:
- name: callsign
  id: variable
  parameters:
    comment: Your station callsign (up to 6 chars).
    value: '"N0CALL"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: |-
      Dial frequency in Hz. OFDM occupies center_freq + 500 Hz to
      center_freq + 3500 Hz (USB, upper sideband). Examples:
      14.074e6 = 20m digital, 7.074e6 = 40m digital.
    value: 14.074e6
  states: {}
- name: force_tier
  id: variable
  parameters:
    comment: |-
      ACM tier override: -1 = adaptive.
      0=50Hz survival (~100s/msg), 4=2kHz QPSK (~1kbps), 8=3.5kHz 16QAM (~5kbps).
    value: '-1'
  states: {}
- name: hackrf_rate
  id: variable
  parameters:
    comment: |-
      HackRF sample rate. Must be a whole multiple of samp_rate.
      2 MHz is the HackRF minimum and gives a 250:1 resampling ratio.
      4 MHz (ratio 500:1) also works if you need a wider spectrum view.
    value: '2000000'
  states: {}
- name: rx_bb_gain
  id: variable
  parameters:
    comment: HackRF RX baseband (VGA) gain (dB). 0–62 dB in 2 dB steps.
    value: '16'
  states: {}
- name: rx_if_gain
  id: variable
  parameters:
    comment: HackRF RX IF (LNA) gain (dB). 0–40 dB in 8 dB steps.
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Modem audio rate — fixed at 8000 Hz by opendsp-ofdm design.
    value: '8000'
  states: {}
- name: transmit
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      PTT — check BEFORE sending a message. Uncheck when TX finishes.
      Calls osmosdr_transceiver.set_transmit(True/False) to switch the
      HackRF between transmit and receive modes.
    'false': 'False'
    gui_hint: 0,0,1,1
    label: PTT (Transmit)
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: HackRF TX IF gain (dB). Range 0–47 dB in 1 dB steps.
    value: '47'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    comment: |-
      USB demodulation: take the I (real) component of the
      downsampled complex signal. Equivalent to a synchronous
      USB detector tuned to center_freq.
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      Decoded frames printed in the GRC console.
      PDU format: ({callsign, tier, fec_ok}, decoded_text)
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: |-
      Converts real audio to a complex analytic signal, producing
      a single-sideband (USB) envelope. Without this, the upconverted
      signal would have mirror images on both sides of center_freq.
      65 taps gives good stop-band rejection across the 4 kHz audio band.
    num_taps: '65'
  states: {}
- name: opendsp_ofdm_rx_sink_0
  id: opendsp_ofdm_rx_sink
  parameters:
    callsign: callsign
    comment: |-
      OFDM modem RX. Searches for ZC preamble sync, demodulates
      symbols, applies LDPC FEC, and posts decoded frames to frame_out.
      Verbose prints per-symbol SNR and ACM tier to the console.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: opendsp_ofdm_tx_source_0
  id: opendsp_ofdm_tx_source
  parameters:
    callsign: callsign
    comment: |-
      OFDM modem TX. Outputs real-valued audio-band OFDM at 8 kHz.
      Output is silence (zeros) between transmissions.
      With force_tier=-1 the ACM engine adapts based on the last
      negotiated tier from the remote station.
    force_tier: force_tier
    verbose: 'True'
  states: {}
- name: osmosdr_transceiver_0
  id: osmosdr_transceiver
  parameters:
    args: ''
    bandwidth: '0'
    center_freq: center_freq
    comment: |-
      Half-duplex HackRF transceiver.
      TX input and RX output share the same center_freq.
      PTT checkbox controls set_transmit(True/False).
      The OFDM signal occupies center_freq + 500 Hz to
      center_freq + 3500 Hz in the upper sideband.
    freq_corr: '0'
    rf_gain: '0'
    rx_bb_gain: rx_bb_gain
    rx_if_gain: rx_if_gain
    sample_rate: hackrf_rate
    transmit: transmit
    tx_gain: tx_gain
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: |-
      Check PTT first, then type a message and press Enter.
      The TX source encodes, applies LDPC FEC, and streams OFDM
      samples to the HackRF at hackrf_rate.
    gui_hint: tab@0:0,0,1,2
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message (check PTT first, then press Enter)"'
    type: string
    value: '"Hello via OFDM!"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: hackrf_rate
    comment: |-
      Wideband HF spectrum at the HackRF sample rate.
      The OFDM signal appears as a narrow ridge near center_freq.
      Span = hackrf_rate = 2 MHz (+/-1 MHz from center_freq).
    fc: center_freq
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@1:0,0,1,2
    label: '"HackRF RX Spectrum"'
    name: '"HackRF RX Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: |-
      TX OFDM audio spectrum at 8 kHz. The occupied bandwidth
      shifts with ACM tier: 50 Hz (tier 0) to 3.5 kHz (tier 8).
      Frequencies shown are the audio-band offsets; add center_freq
      to get the on-air RF frequencies.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:1,0,1,2
    label: '"TX Audio Spectrum"'
    name: '"TX Audio Spectrum"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Upsample from modem rate (8 kHz) to HackRF rate (2 MHz).
      interp = hackrf_rate / samp_rate = 250.
      The built-in anti-imaging filter limits the signal to < 4 kHz.
    decim: '1'
    interp: '250'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Downsample from HackRF rate (2 MHz) to modem rate (8 kHz).
      decim = hackrf_rate / samp_rate = 250.
      The anti-aliasing filter prevents out-of-band signals
      from folding into the 0–4 kHz modem passband.
    decim: '250'
    interp: '1'
    type: ccf
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: TX
    label1: RX
    num_tabs: '2'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', opendsp_ofdm_rx_sink_0, '0']
- [hilbert_fc_0, '0', rational_resampler_xxx_0, '0']
- [opendsp_ofdm_rx_sink_0, frame_out, blocks_message_debug_0, print]
- [opendsp_ofdm_tx_source_0, '0', hilbert_fc_0, '0']
- [opendsp_ofdm_tx_source_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_transceiver_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_transceiver_0, '0', rational_resampler_xxx_1, '0']
- [qtgui_edit_box_msg_0, msg, opendsp_ofdm_tx_source_0, msg_in]
- [rational_resampler_xxx_0, '0', osmosdr_transceiver_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
